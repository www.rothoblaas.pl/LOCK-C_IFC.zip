Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: f6a4e55c-343f-4ba0-a6fe-a22c60543296, NumberOfSaves: 38], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_LockC_A_75175.ifc
Time: 2026-04-30T16:38:19
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_LockC_A_75175 : LOCKC75175_075x175x22mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_LockC_A; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/lock-c; Revision: 2; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.41; Version: 2
Type - Constraints - Default Elevation: 0 mm; ModelNumberCode: 75175
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium
Type - Dimensions - AnchorsQuantity_nanchors_Ø10: 2; AnchorsQuantity_nanchors_Ø8: 0; Depth_P: 22 mm; Distance_d: 13.1 mm; Height_H: 175 mm; HoleQuantity_nscrews_Ø5: 0; HoleQuantity_nscrews_Ø7: 12; Width_B: 75 mm
Type - Identity Data - Description: Concealed hook timber-to-concrete connector; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.13.23.11.19.13; Type Name: LOCKC75175_075x175x22mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: ETA-19/0831; CETitle: Rotho Blaas LOCK Connectors; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_LockC_A_75175; Features: Bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: n/a; Grade: n/a; GTIN: 8052877751594; Material: Aluminium; MinWeight: 0.45 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website / This model is a component of Lock C, the product is only available as an assembly; ModelNumber: LOCKC75175; ModelReference: n/a; Name: Plate; NominalDepth: 22 mm; NominalHeight: 175 mm; NominalLength: n/a; NominalWidth: 75 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 75x175x22 mm; Size_Imperial: 2 15/16x6 7/8x0.87 in; SustainabilityPerformance: BVB Accepted / Sundahus B; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: LOCKC75175_075x175x22mm
Pset_QuantityTakeOff - Reference: LOCKC75175_075x175x22mm
BaseQuantities - NetVolume: 0.0000807457 m3; NetSurfaceArea: 0.03159 m2
Constraints - Elevation from Level: 0 mm; Host: Reference Plane; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0000807457 m3
Other - Family: ROTHOB_Rothoblaas_Plate_LockC_A_75175; Family and Type: ROTHOB_Rothoblaas_Plate_LockC_A_75175: LOCKC75175_075x175x22mm; InstallationDate: n/a; Type: LOCKC75175_075x175x22mm; Type Id: 1723920; WarrantyStartDate: n/a
