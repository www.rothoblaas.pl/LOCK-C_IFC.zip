Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: f6a4e55c-343f-4ba0-a6fe-a22c60543296, NumberOfSaves: 38], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_LockC_B_100215.ifc
Time: 2026-04-30T16:47:39
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_LockC_B_100215 : LOCKC100215_100x215x22mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_LockC_B; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/lock-c; Revision: 2; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.41; Version: 2
Type - Constraints - Default Elevation: 0 mm; ModelNumberCode: 100215
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium
Type - Dimensions - AnchorsQuantity_nanchors_Ø10: 4; AnchorsQuantity_nanchors_Ø8: 0; Depth_P: 22 mm; Distance_d: 13.08 mm; Height_H: 215 mm; HoleQuantity_nscrews_Ø5: 0; HoleQuantity_nscrews_Ø7: 24; Width_B: 100 mm
Type - Identity Data - Description: Concealed hook timber-to-concrete connector; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.13.23.11.19.13; Type Name: LOCKC100215_100x215x22mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: ETA-19/0831; CETitle: Rotho Blaas LOCK Connectors; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_LockC_B_100215; Features: Bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: n/a; Grade: n/a; GTIN: 8052877751600; Material: Aluminium; MinWeight: 0.71 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website / This model is a component of Lock C, the product is only available as an assembly.; ModelNumber: LOCKC100215; ModelReference: n/a; Name: Plate; NominalDepth: 22 mm; NominalHeight: 215 mm; NominalLength: n/a; NominalWidth: 100 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 100x215x22 mm; Size_Imperial: 4x8 7/16x0.87 in; SustainabilityPerformance: BVB Accepted / Sundahus B; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: LOCKC100215_100x215x22mm
Pset_QuantityTakeOff - Reference: LOCKC100215_100x215x22mm
BaseQuantities - Length: 100 mm; CrossSectionArea: 0.00137428 m2; OuterSurfaceArea: 0.0473865 m2; GrossSurfaceArea: 0.050135 m2; GrossVolume: 0.000137428 m3; NetVolume: 0.000130551 m3; NetSurfaceArea: 0.0514733 m2
Constraints - Elevation from Level: 0 mm; Host: Reference Plane; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.000130551 m3
Other - Family: ROTHOB_Rothoblaas_Plate_LockC_B_100215; Family and Type: ROTHOB_Rothoblaas_Plate_LockC_B_100215: LOCKC100215_100x215x22mm; InstallationDate: n/a; Type: LOCKC100215_100x215x22mm; Type Id: 1717785; WarrantyStartDate: n/a

# IfcOpeningElement: Opening (24)
In: 0_Rothoblaas
BaseQuantities - Depth: 100 mm; Area: 0.00137428 m2
Pset_OpeningElementCommon - Reference: LOCKC100215_100x215x22mm; sets with these values: 2
Name (Structural Connections : ROTHOB_Rothoblaas_Plate_LockC_B_100215 : LOCKC100215_100x215x22mm:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
